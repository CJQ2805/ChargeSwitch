# Keil uVision project FATFS_SD.uvprojx, settings and files
target FATFS_SD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FATFS_SD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Src\drv\tim;..\Src\drv\uart;..\Src\drv\sdio;..\Src\drv\sys;..\Src\drv\fmc;..\Src\module\tftlcd;..\Middlewares\Third_Party\FreeRTOS\Source;..\Src\tools;..\Src\middle\fatfs;..\Src\module\sd_card;..\Src\tools\key;..\Src\middle\GUI;..\Src\middle\GUI\lvgl;..\Src\middle\GUI\lvgl\examples\porting;..\Src\middle\GUI\lvgl_app\lv_examples\src\lv_demo_widgets;..\Src\module\gui;..\Src\middle\GUI\lvgl_imge;..\Src\module\gui;..\Src\drv\rtc;..\Src\drv\standby;..\Src\drv\lcd_dma;..\Src\drv\TOUCH;..\Src\drv\SDRAM;..\Src\module\gui\APP_font
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: osmonit.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group tools
    ../Src/tools/: log.c
    ../Src/tools/key/: key.c
  group middle/fatfs
    ../Src/middle/fatfs/: bsp_driver_sd.c fatfs.c sd_diskio.c
  group module/lcd
    ../Src/module/tftlcd/: tftlcd_opr.c tftlcd_arg.c
  group module/gui
    ../Src/module/gui/: gui_app_anim.c gui_app_test.c
  group module/sd_card
    ../Src/module/sd_card/: sd_card_opr.c sd_card_process.c
  group drv
    ../Src/drv/tim/: tim.c
    ../Src/drv/fmc/: fmc.c
    ../Src/drv/rtc/: rtc.c
    ../Src/drv/uart/: usart.c
    ../Src/drv/sdio/: sdio.c
    ../Src/drv/standby/: low_power.c
    ../Src/drv/sys/: SysCommDef.c
    ../Src/drv/lcd_dma/: lcd_dma.c
    ../Src/drv/TOUCH/: touch.c ott2001a.c gt9271.c gt9147.c ft5206.c ctiic.c
    ../Src/drv/SDRAM/: sdram.c
  group middle/lvgl/porting
    ../Src/middle/GUI/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group middle/lvgl/app
    ../Src/middle/GUI/lvgl_app/lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
  group middle/lvgl/src
    ../Src/middle/GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Src/middle/GUI/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Src/middle/GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_dejavu_16_persian_hebrew.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Src/middle/GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Src/middle/GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Src/middle/GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../Src/middle/GUI/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    ../Src/module/gui/APP_font/: my_font_icon_num60.c
  group middle/lvgl/imge
    ../Src/middle/GUI/lvgl_imge/: heart.c
software components: CMSIS:CORE 5.1.2
